options:
  parameters:
    generate_options: qt_gui
    id: stop_wait_ack
    output_language: python
    title: Stop and Wait ACK example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: gwn3_event_sink_0
  id: gwn3_event_sink
  parameters:
    ev_count: 'True'
  states: {}
- name: gwn3_event_sink_1
  id: gwn3_event_sink
  parameters:
    ev_count: 'True'
  states: {}
- name: gwn3_event_source_0
  id: gwn3_event_source
  parameters:
    ev_count: '5'
    ev_dc: '{''Type'':''Data'', ''Subtype'':''Data'', ''seq_nr'':0}'
    interval: '1.0'
  states: {}
- name: gwn3_stop_wait_ack_0
  id: gwn3_stop_wait_ack
  parameters:
    ack_to_send: '{''Type'': ''Ctrl'', ''Subtype'': ''ACK''}'
    debug: 'False'
    ev_to_ack: '{''Type'':''Data'', ''Subtype'':''Data''}'
  states: {}

connections:
- [gwn3_event_source_0, out_0, gwn3_stop_wait_ack_0, in_0]
- [gwn3_stop_wait_ack_0, out_0, gwn3_event_sink_0, in_0]
- [gwn3_stop_wait_ack_0, out_1, gwn3_event_sink_1, in_0]

metadata:
  file_format: 1
