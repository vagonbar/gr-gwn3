options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: packet_loopback_hier
    output_language: python
  states: {}

blocks:
- name: Const_HDR
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {}
- name: Const_PLD
  id: variable_constellation
  parameters:
    const_points: digital.psk_4()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_4()[1]
    type: calcdist
  states: {}
- name: Const_PLD
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '2'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {state: disabled}
- name: amp
  id: variable_qtgui_range
  parameters:
    label: Amplitude
    start: '0'
    step: '0.01'
    stop: '2'
    value: '1.0'
  states: {}
- name: dec
  id: variable_cc_decoder_def
  parameters:
    framebits: '8000'
    k: k
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_end: '-1'
    state_start: '0'
  states: {}
- name: dec
  id: variable_dummy_decoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
  states: {state: disabled}
- name: dec
  id: variable_repetition_decoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
    prob: '0.5'
    rep: rep
  states: {state: disabled}
- name: dec_hdr
  id: variable_dummy_decoder_def
  parameters:
    framebits: hdr_format.header_nbits()
    ndim: '0'
  states: {state: disabled}
- name: dec_hdr
  id: variable_repetition_decoder_def
  parameters:
    framebits: hdr_format.header_nbits()
    ndim: '0'
    prob: '0.5'
    rep: rep
  states: {state: disabled}
- name: eb
  id: variable
  parameters:
    value: '0.22'
  states: {}
- name: enc
  id: variable_cc_encoder_def
  parameters:
    framebits: '8000'
    k: k
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_start: '0'
  states: {}
- name: enc
  id: variable_dummy_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
  states: {state: disabled}
- name: enc
  id: variable_repetition_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
    rep: rep
  states: {state: disabled}
- name: enc_hdr
  id: variable_dummy_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
  states: {state: disabled}
- name: enc_hdr
  id: variable_repetition_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
    rep: rep
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Freq. Offset
    start: '-0.5'
    step: '0.0001'
    stop: '0.5'
    value: '0'
  states: {}
- name: hdr_format
  id: variable_header_format_default
  parameters:
    access_code: digital.packet_utils.default_access_code
    bps: '1'
    threshold: '3'
  states: {state: disabled}
- name: hdr_format
  id: variable
  parameters:
    value: digital.header_format_counter(digital.packet_utils.default_access_code, 3, Const_PLD.bits_per_symbol())
  states: {state: disabled}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Noise Amp
    start: '0'
    step: '0.01'
    stop: '5'
    value: '0.0'
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: rate
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rep
  id: variable
  parameters:
    value: '3'
  states: {}
- name: rx_rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: eb
    gain: nfilts
    ntaps: 11*sps*nfilts
    samp_rate: nfilts*sps
    sym_rate: '1.0'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: time_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,2,1,1
    label: Time Offset
    start: '0.99'
    step: '0.00001'
    stop: '1.01'
    value: '1.0'
  states: {}
- name: tx_rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: eb
    gain: nfilts
    ntaps: 5*sps*nfilts
    samp_rate: nfilts
    sym_rate: '1.0'
  states: {}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amp
    type: complex
  states: {}
- name: blocks_random_pdu_0
  id: blocks_random_pdu
  parameters:
    length_modulo: '2'
    mask: '0xFF'
    maxsize: '200'
    minsize: '20'
  states: {}
- name: chan_data
  id: virtual_sink
  parameters:
    stream_id: Chan Data
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: time_offset
    freq_offset: freq_offset
    noise_voltage: noise
    seed: '0'
    taps: '1.0'
  states: {}
- name: gwn3_packet_rx_gwn_0
  id: gwn3_packet_rx_gwn
  parameters:
    eb: '0.35'
    hdr_const: digital.constellation_calcdist((digital.psk_2()[0]), (digital.psk_2()[1]), 2, 1).base()
    hdr_dec: ' fec.dummy_decoder.make(8000)'
    hdr_format: digital.header_format_default(digital.packet_utils.default_access_code, 0)
    pld_const: digital.constellation_calcdist((digital.psk_2()[0]), (digital.psk_2()[1]), 2, 1).base()
    pld_dec: ' fec.dummy_decoder.make(8000)'
    psf_taps: '[0,]'
    sps: '2'
  states: {}
- name: gwn3_packet_tx_gwn_0
  id: gwn3_packet_tx_gwn
  parameters:
    hdr_const: digital.constellation_calcdist((digital.psk_2()[0]), (digital.psk_2()[1]), 2, 1).base()
    hdr_enc: ' fec.dummy_encoder_make(8000)'
    hdr_format: digital.header_format_default(digital.packet_utils.default_access_code, 0)
    pld_const: digital.constellation_calcdist((digital.psk_2()[0]), (digital.psk_2()[1]), 2, 1).base()
    pld_enc: ' fec.dummy_encoder_make(8000)'
    psf_taps: '[0,]'
    sps: '2'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tab0@2
    legend: 'False'
    size: '1024'
    tr_tag: packet_len
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tab1@2
    legend: 'False'
    size: '800'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '1'
    fc: '0'
    fftsize: '1024'
    gui_hint: tab0@1
    legend: 'False'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '1'
    fc: '0'
    fftsize: '1024'
    gui_hint: tab1@1
    legend: 'False'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab0@0
    label1: ''
    label2: ''
    legend: 'False'
    size: '2500'
    srate: '1'
    tr_tag: packet_len
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,0,1,1
    label1: ''
    label2: ''
    legend: 'False'
    size: '1250'
    srate: '1'
    tr_delay: '50'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"corr_est"'
    type: complex
    ylabel: Correlation
    ymax: '150'
    ymin: '-150'
  states: {}
- name: qtgui_time_sink_x_1_0_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab1@0
    label1: ''
    label2: ''
    legend: 'False'
    marker1: '0'
    size: '125'
    srate: '1'
    style1: '3'
    tr_delay: '25'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"payload symbols"'
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: tab0
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,1,1,1
    label0: Time
    label1: Freq.
    label2: Const.
    num_tabs: '3'
  states: {}
- name: tab1
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,2,1,1
    label0: Time
    label1: Freq.
    label2: Const.
    num_tabs: '3'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Chan Data
  states: {}

connections:
- [blocks_message_strobe_0, strobe, blocks_random_pdu_0, generate]
- [blocks_multiply_const_vxx_0, '0', gwn3_packet_rx_gwn_0, '0']
- [blocks_random_pdu_0, pdus, gwn3_packet_tx_gwn_0, in]
- [channels_channel_model_0, '0', chan_data, '0']
- [channels_channel_model_0, '0', qtgui_const_sink_x_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0, '0']
- [channels_channel_model_0, '0', qtgui_time_sink_x_1, '0']
- [gwn3_packet_rx_gwn_0, '0', qtgui_time_sink_x_1_0_0_0, '0']
- [gwn3_packet_rx_gwn_0, '1', qtgui_const_sink_x_0_0_0, '0']
- [gwn3_packet_rx_gwn_0, '1', qtgui_freq_sink_x_0_0, '0']
- [gwn3_packet_rx_gwn_0, '1', qtgui_time_sink_x_1_0_0_1, '0']
- [gwn3_packet_rx_gwn_0, pkt out, blocks_message_debug_0_0_0, print_pdu]
- [gwn3_packet_tx_gwn_0, '0', channels_channel_model_0, '0']
- [virtual_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
