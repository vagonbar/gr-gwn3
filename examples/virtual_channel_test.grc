options:
  parameters:
    generate_options: qt_gui
    id: event_source_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: gwn3_event_sink_0
  id: gwn3_event_sink
  parameters:
    ev_count: 'True'
  states: {}
- name: gwn3_event_source_0
  id: gwn3_event_source
  parameters:
    ev_count: '10'
    ev_dc: '{''Type'':''Data'', ''Sutbtype'':''TestData'', ''seq_nr'':0}'
    interval: '1.0'
  states: {}
- name: gwn3_virtual_channel_0
  id: gwn3_virtual_channel
  parameters:
    prob_loss: '0.5'
  states: {}

connections:
- [gwn3_event_source_0, out_0, gwn3_virtual_channel_0, in_0]
- [gwn3_virtual_channel_0, out_0, gwn3_event_sink_0, in_0]

metadata:
  file_format: 1
