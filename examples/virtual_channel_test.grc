options:
  parameters:
    author: victor
    generate_options: qt_gui
    id: virtual_channel_test
    output_language: python
    title: Virtual channel
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: gwn3_msg_sink_0
  id: gwn3_msg_sink
  parameters: {}
  states: {}
- name: gwn3_msg_source_0
  id: gwn3_msg_source
  parameters:
    interval: '1.0'
    msg_count: '10'
    payload: A payload to be lost
  states: {}
- name: gwn3_virtual_channel_0
  id: gwn3_virtual_channel
  parameters:
    prob_loss: '0.5'
  states: {}

connections:
- [gwn3_msg_source_0, out_0, gwn3_virtual_channel_0, in_0]
- [gwn3_virtual_channel_0, out_0, gwn3_msg_sink_0, in_0]

metadata:
  file_format: 1
