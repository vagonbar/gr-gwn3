options:
  parameters:
    generate_options: qt_gui
    id: ev_to_pdu
    output_language: python
    title: Event to PDU
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: gwn3_ev_to_pdu_0
  id: gwn3_ev_to_pdu
  parameters: {}
  states: {}
- name: gwn3_msg_source_0
  id: gwn3_msg_source
  parameters:
    interval: '1'
    msg_count: '10'
    payload: MESSAGE
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}

connections:
- [gwn3_ev_to_pdu_0, pdu, pdu_pdu_to_tagged_stream_0, pdus]
- [gwn3_msg_source_0, out_0, gwn3_ev_to_pdu_0, in_0]
- [pdu_pdu_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print_pdu]

metadata:
  file_format: 1
  grc_version: 3.10.5.1
