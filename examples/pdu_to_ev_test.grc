options:
  parameters:
    generate_options: qt_gui
    id: pdu_to_ev
    output_language: python
    title: PDU to event
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: gwn3_ev_to_pdu_0
  id: gwn3_ev_to_pdu
  parameters: {}
  states: {}
- name: gwn3_msg_sink_0
  id: gwn3_msg_sink
  parameters: {}
  states: {}
- name: gwn3_msg_source_0
  id: gwn3_msg_source
  parameters:
    interval: '1.0'
    msg_count: '10'
    payload: MY MESSAGE
  states: {}
- name: gwn3_pdu_to_ev_0
  id: gwn3_pdu_to_ev
  parameters: {}
  states: {}

connections:
- [gwn3_ev_to_pdu_0, pdu, gwn3_pdu_to_ev_0, pdu]
- [gwn3_msg_source_0, out_0, gwn3_ev_to_pdu_0, in_0]
- [gwn3_pdu_to_ev_0, out_0, gwn3_msg_sink_0, in_0]

metadata:
  file_format: 1
