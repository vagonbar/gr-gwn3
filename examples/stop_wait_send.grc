options:
  parameters:
    author: Stop and Wait send example
    generate_options: qt_gui
    id: stop_wait_send
    output_language: python
    title: 'Stop and Wait send '
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: gwn3_event_source_0
  id: gwn3_event_source
  parameters:
    ev_count: '10'
    ev_dc: '{''Type'': ''Data'', ''Subtype'': ''Data'', ''seq_nr'':0}'
    interval: '1.0'
  states: {}
- name: gwn3_msg_sink_0
  id: gwn3_msg_sink
  parameters: {}
  states: {}
- name: gwn3_msg_sink_1
  id: gwn3_msg_sink
  parameters: {}
  states: {}
- name: gwn3_stop_wait_ack_0
  id: gwn3_stop_wait_ack
  parameters:
    ack_to_send: '{''Type'': ''Ctrl'', ''Subtype'': ''ACK''}'
    debug: 'False'
    ev_to_ack: '{''Type'': ''Data'', ''Subtype'': ''Data''}'
  states: {}
- name: gwn3_stop_wait_send_0
  id: gwn3_stop_wait_send
  parameters:
    ack_name: CtrlAck
    buffer_len: '3'
    debug: 'False'
    max_retries: '5'
    timeout: '0.5'
    tout_name: TimerACKTout
  states: {}
- name: gwn3_virtual_channel_0
  id: gwn3_virtual_channel
  parameters:
    prob_loss: '0.5'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: MsgChan
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: MsgChan
  states: {}

connections:
- [gwn3_event_source_0, out_0, gwn3_stop_wait_send_0, in_0]
- [gwn3_stop_wait_ack_0, out_0, gwn3_msg_sink_0, in_0]
- [gwn3_stop_wait_ack_0, out_1, gwn3_msg_sink_1, in_0]
- [gwn3_stop_wait_ack_0, out_1, virtual_sink_0, '0']
- [gwn3_stop_wait_send_0, out_0, gwn3_virtual_channel_0, in_0]
- [gwn3_virtual_channel_0, out_0, gwn3_stop_wait_ack_0, in_0]
- [virtual_source_0, '0', gwn3_stop_wait_send_0, in_0]

metadata:
  file_format: 1
