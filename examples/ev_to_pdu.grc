options:
  parameters:
    generate_options: qt_gui
    id: ev_to_pdu
    output_language: python
    title: Event to PDU
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: gwn3_ev_to_pdu_0
  id: gwn3_ev_to_pdu
  parameters: {}
  states: {}
- name: gwn3_msg_source_0
  id: gwn3_msg_source
  parameters:
    interval: '1'
    msg_count: '10'
    payload: MESSAGE
  states: {}

connections:
- [blocks_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print_pdu]
- [gwn3_ev_to_pdu_0, pdu, blocks_pdu_to_tagged_stream_0, pdus]
- [gwn3_msg_source_0, out_0, gwn3_ev_to_pdu_0, in_0]

metadata:
  file_format: 1
