options:
  parameters:
    generate_options: qt_gui
    id: packet_tx_rx_test
    output_language: python
    title: Packet Tx Rx test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {}
- name: blocks_probe_signal_x_0
  id: blocks_probe_signal_x
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_probe_signal_x_0_0
  id: blocks_probe_signal_x
  parameters:
    type: complex
  states: {}
- name: blocks_random_pdu_0
  id: blocks_random_pdu
  parameters:
    length_modulo: '2'
    mask: '0xFF'
    maxsize: '200'
    minsize: '20'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: '1.0'
  states: {state: disabled}
- name: gwn3_packet_rx_gwn_0
  id: gwn3_packet_rx_gwn
  parameters: {}
  states: {}
- name: gwn3_packet_tx_gwn_0
  id: gwn3_packet_tx_gwn
  parameters: {}
  states: {}

connections:
- [blocks_message_strobe_0, strobe, blocks_random_pdu_0, generate]
- [blocks_random_pdu_0, pdus, gwn3_packet_tx_gwn_0, in]
- [channels_channel_model_0, '0', blocks_probe_signal_x_0, '0']
- [channels_channel_model_0, '0', gwn3_packet_rx_gwn_0, '0']
- [gwn3_packet_tx_gwn_0, '0', blocks_probe_signal_x_0_0, '0']
- [gwn3_packet_tx_gwn_0, '0', channels_channel_model_0, '0']
- [gwn3_packet_tx_gwn_0, '0', gwn3_packet_rx_gwn_0, '0']
- [gwn3_packet_tx_gwn_0, postcrc, blocks_message_debug_0_0_0, print_pdu]

metadata:
  file_format: 1
