options:
  parameters:
    generate_options: qt_gui
    id: packet_tx_rx_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1000'
  states: {}
- name: blocks_random_pdu_0
  id: blocks_random_pdu
  parameters:
    length_modulo: '2'
    mask: '0xFF'
    maxsize: '200'
    minsize: '20'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: '1.0'
  states: {}
- name: gwn3_packet_rx_gwn_0
  id: gwn3_packet_rx_gwn
  parameters:
    eb: '0.35'
    hdr_const: '''digital.constellation_calcdist((digital.psk_2()[0]), (digital.psk_2()[1]), 2, 1).base()'''
    hdr_dec: '''fec.dummy_decoder.make(8000)'''
    hdr_format: '''digital.header_format_default(digital.packet_utils.default_access_code, 0)'''
    pld_const: '''digital.constellation_calcdist((digital.psk_2()[0]), (digital.psk_2()[1]), 2, 1).base()'''
    pld_dec: '''fec.dummy_decoder.make(8000)'''
    psf_taps: '[0,]'
    sps: '2'
  states: {}
- name: gwn3_packet_tx_gwn_0
  id: gwn3_packet_tx_gwn
  parameters:
    hdr_const: '''digital.constellation_calcdist((digital.psk_2()[0]), (digital.psk_2()[1]), 2, 1).base()'''
    hdr_enc: '''fec.dummy_encoder_make(8000)'''
    hdr_format: '''digital.header_format_default(digital.packet_utils.default_access_code, 0)'''
    pld_const: '''digital.constellation_calcdist((digital.psk_2()[0]), (digital.psk_2()[1]), 2, 1).base()'''
    pld_enc: '''fec.dummy_encoder_make(8000)'''
    psf_taps: '[0,]'
    sps: '2'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, blocks_random_pdu_0, generate]
- [blocks_random_pdu_0, pdus, gwn3_packet_tx_gwn_0, in]
- [channels_channel_model_0, '0', gwn3_packet_rx_gwn_0, '0']
- [gwn3_packet_rx_gwn_0, pkt out, blocks_message_debug_0_0_0, print_pdu]
- [gwn3_packet_tx_gwn_0, '0', channels_channel_model_0, '0']

metadata:
  file_format: 1
