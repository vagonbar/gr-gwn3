options:
  parameters:
    generate_options: qt_gui
    id: pasador2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: gwn3_msg_passer_0
  id: gwn3_msg_passer
  parameters:
    tout_restart: '7'
    tout_stop: '4'
  states: {}
- name: gwn3_msg_sink_0
  id: gwn3_msg_sink
  parameters: {}
  states: {}
- name: gwn3_msg_source_0
  id: gwn3_msg_source
  parameters:
    interval: '1'
    msg_count: '10'
    payload: El Mensaje
  states: {}

connections:
- [gwn3_msg_passer_0, out_port_0, gwn3_msg_sink_0, in_port_0]
- [gwn3_msg_source_0, out_port_0, gwn3_msg_passer_0, in_port_0]

metadata:
  file_format: 1
