options:
  parameters:
    generate_options: qt_gui
    id: gwn_msg_tx_rx_channel_test
    output_language: python
    title: GWN Tx Rx test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.0'
    type: complex
  states: {}
- name: chan_data_0
  id: virtual_sink
  parameters:
    stream_id: '''Channel Data'''
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: '1.0'
  states: {}
- name: gwn3_ev_to_pdu_0
  id: gwn3_ev_to_pdu
  parameters: {}
  states: {}
- name: gwn3_event_sink_0
  id: gwn3_event_sink
  parameters:
    ev_count: 'True'
  states: {}
- name: gwn3_event_source_0
  id: gwn3_event_source
  parameters:
    ev_count: '5'
    ev_dc: '{"type":"Data", "subtype":"Data","payload":"A TEST message"}'
    interval: '1.0'
  states: {}
- name: gwn3_packet_rx_gwn_0
  id: gwn3_packet_rx_gwn
  parameters:
    eb: '0.22'
    hdr_const: ''''''
    hdr_dec: ''''''
    hdr_format: ''''''
    pld_const: ''''''
    pld_dec: ''''''
    psf_taps: ''''''
    sps: '2'
  states: {}
- name: gwn3_packet_tx_gwn_0
  id: gwn3_packet_tx_gwn
  parameters:
    eb: '0.22'
    hdr_const: ''''''
    hdr_enc: ''''''
    hdr_format: ''''''
    pld_const: ''''''
    pld_enc: ''''''
    psf_taps: ''''''
    sps: '2'
  states: {}
- name: gwn3_pdu_to_ev_0
  id: gwn3_pdu_to_ev
  parameters: {}
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '''Channel Data'''
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', gwn3_packet_rx_gwn_0, '0']
- [channels_channel_model_0, '0', chan_data_0, '0']
- [gwn3_ev_to_pdu_0, pdu, gwn3_packet_tx_gwn_0, in]
- [gwn3_event_source_0, out_0, gwn3_ev_to_pdu_0, in_0]
- [gwn3_packet_rx_gwn_0, pkt out, gwn3_pdu_to_ev_0, pdu]
- [gwn3_packet_tx_gwn_0, '0', channels_channel_model_0, '0']
- [gwn3_pdu_to_ev_0, out_0, gwn3_event_sink_0, in_0]
- [virtual_source_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
