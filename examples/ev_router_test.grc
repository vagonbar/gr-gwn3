options:
  parameters:
    generate_options: qt_gui
    id: ev_router_example
    output_language: python
    title: Event router example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: gwn3_event_router_0
  id: gwn3_event_router
  parameters:
    field_nm_0: Subtype
    field_nm_1: Subtype
    field_val_0: Pass_0
    field_val_1: Pass_1
  states: {}
- name: gwn3_event_sink_0
  id: gwn3_event_sink
  parameters:
    ev_count: 'True'
  states: {}
- name: gwn3_event_sink_1
  id: gwn3_event_sink
  parameters:
    ev_count: 'True'
  states: {}
- name: gwn3_event_source_0
  id: gwn3_event_source
  parameters:
    ev_count: '10'
    ev_dc: '{''Type'':''Data'',''Subtype'':''Pass_0''}'
    interval: '0.5'
  states: {}
- name: gwn3_event_source_1
  id: gwn3_event_source
  parameters:
    ev_count: '5'
    ev_dc: '{''Type'':''Data'',''Subtype'':''Pass_1''}'
    interval: '1.0'
  states: {}
- name: gwn3_event_source_2
  id: gwn3_event_source
  parameters:
    ev_count: '5'
    ev_dc: '{''Type'':''Data'',''Subtype'':''NoPass''}'
    interval: '1.0'
  states: {}

connections:
- [gwn3_event_router_0, out_0, gwn3_event_sink_0, in_0]
- [gwn3_event_router_0, out_1, gwn3_event_sink_1, in_0]
- [gwn3_event_source_0, out_0, gwn3_event_router_0, in_0]
- [gwn3_event_source_1, out_0, gwn3_event_router_0, in_0]
- [gwn3_event_source_2, out_0, gwn3_event_router_0, in_0]

metadata:
  file_format: 1
